# IAR project RC_Temperature.ewp, settings and files
configuration srf05_cc2530 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\Components\utils; ..\..\..\Components\common; ..\..\..\Components\basicrf; ..\..\..\Components\targets\interface; ..\..\..\Components\assembly; ..\..\..\Components\common\cc8051; ..\..\..\Components\targets\srf05_soc; ..\..\..\Components\radios\cc2530; ..\..\..\Components\ds18b20; ..\..\..\Components\uart
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256.xcl
  group App
    ../App/: main.c
  group basic rf
    ../../../Components/basicrf/: basic_rf.c basic_rf_security.c
    ../../../source/Components/basicrf/: basic_rf.h basic_rf_security.h
  group ds18b20
    ../../../Components/ds18b20/: ds18b20.c
  group hal/common
    ../../../source/Components/common/cc8051/: hal_cc8051.h
    ../../../source/Components/common/: hal_defs.h hal_types.h
    ../../../Components/common/: hal_int.c
    ../../../Components/targets/common/: hal_lcd_srf05.c
  group hal/interface
    ../../../source/Components/targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h
  group hal/rf
    ../../../source/Components/targets/interface/: hal_rf.h hal_rf_security.h
  group hal/rf/cc2530
    ../../../Components/radios/cc2530/: adc.c clock.c hal_mcu.c hal_rf.c hal_rf_security.c hal_rf_util.c
    ../../../source/Components/radios/cc2530/: adc.h clock.h
  group hal/srf05_soc
    ../../../Components/targets/srf05_soc/: hal_assert.c hal_board.c hal_button.c hal_digio.c hal_joystick.c hal_led.c
    ../../../source/Components/targets/srf05_soc/: hal_board.h
  group uart
    ../../../Components/uart/: uart.c
  group utilities
    ../../../Components/utils/: util.c util_buffer.c util_lcd.c
    ../../../source/Components/utils/: util.h util_buffer.h util_lcd.h
